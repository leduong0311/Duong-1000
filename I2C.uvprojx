# Keil uVision project I2C.uvprojx, settings and files
target I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\..\..\Design_Project\Document\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;.\Src;.\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Design_Project\Document\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Mylib;..\..\..\Desktop\ES_Exam2_UART;..\..\..\Desktop\beginstm;D:\tài li?u các môn h?c\h? th?ng nhúng\btvn nhung\STM32F4xx_StdPeriph_Driver\inc;D:\tài li?u các môn h?c\h? th?ng nhúng\btvn nhung\STM32F4xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./Src/: system_stm32f4xx.c
  group User
    ./Src/: main.c stm32f4xx_it.c
  group Std_Lib
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
    ../../../Desktop/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_syscfg.c misc.c
  group Mylib
    ./Mylib/: DHT12.c DHT12.h Systick.c Systick.h
  group Startup
    ./Src/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.2.0
